# Keil uVision project MyProject.uvproj, settings and files
target MyProject (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: MyProject +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,ARM_MATH_CM4,__CC_ARM
  c misc: --diag_suppress=870
  c include: ..\Source\include;..\Source\portable\RVDS\ARM_CM4F;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\App;..\App\Bsp_Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: Main.c
  group BSP
    ../App/: bsp.c
    ../App/Bsp_Src/: bsp_led.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_syscfg.c
  group DSP_Lib
    ../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group OS_Source
    ../Source/: timers.c tasks.c queue.c list.c croutine.c event_groups.c
  group OS_Portable
    ../Source/portable/RVDS/ARM_CM4F/: port.c
    ../Source/portable/MemMang/: heap_2.c
